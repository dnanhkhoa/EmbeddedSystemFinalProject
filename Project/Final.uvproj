# Keil uVision project Final.uvproj, settings and files
target FinalProject (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: SPI
  c flags: Optim=1
  c define: HSE_VALUE=8000000, USE_STDPERIPH_DRIVER
  c include: .\Lib\ST;.\Lib\CMSIS\inc;.\Driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group CMSIS
    ./Lib/CMSIS/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group My Driver
    ./Driver/: my_button.c my_gpio.c my_led.c my_spi.c
  group User
    ./User/: main.c menu.c
